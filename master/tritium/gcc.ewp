# IAR project gcc.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430dn.h
  General.OGChipSelectMenu: MSP430F247 MSP430F247
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  group (top)
    ./: bms.cc bms.h can.cc can.h charger.cc charger.h gauge.cc gauge.h pedal.cc pedal.h pid.cc pid.h queue.cc readme.txt tri86.cc tri86.h usci.cc usci.h voice.cc voice.h
