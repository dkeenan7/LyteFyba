<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\monitor\monitor.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\monolith\monolith.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TestICal\TestICal.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\wmonolith\wmonolith.ewp</path>
  </project>
  <batchBuild/>
</workspace>


